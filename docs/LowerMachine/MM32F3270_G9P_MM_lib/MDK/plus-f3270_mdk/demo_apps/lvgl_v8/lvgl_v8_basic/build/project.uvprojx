# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F3273G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: LV_CONF_INCLUDE_SIMPLE BRD_PLUS_F3270
  c include: ../../../../components;../../../../components/lvgl_v8/src/extra/themes;..;../../../../components/lvgl_v8/src/extra/widgets/tabview;../../../../components/lvgl_v8/src/extra/libs/sjpg;../../../../device/CMSIS/Include;../../../../components/lvgl_v8/src/extra/libs/png;../../../../components/lvgl_v8/src/extra/widgets/animimg;../../../../components/lvgl_v8/src/extra/widgets/colorwheel;../../../../components/lvgl_v8/src/extra/widgets/spinner;../../../../components/lvgl_v8/src/extra/widgets/tileview;../../../../components/lvgl_v8/src/hal;../../../../components/lvgl_v8/src/extra/themes/default;../../../../components/lvgl_v8/src/extra/libs/gif;../../../../components/lvgl_v8/src/extra/themes/mono;../../../../components/lvgl_v8/src/extra/themes/basic;../../../../components/lvgl_v8/src/extra/libs;../../../../components/lvgl_v8/src/extra/widgets/keyboard;../../../../components/lvgl_v8/src/extra/libs/qrcode;../../../../components/lvgl_v8/src/extra/widgets/list;../../../../components/lvgl_v8/src/font;../../../../components/lvgl_v8/src/draw;../../../../components/lvgl_v8/src/extra/widgets/meter;../../../../components/lvgl_v8/src/extra/layouts/flex;../../../../components/lvgl_v8/src/extra/layouts/grid;../../../../components/lvgl_v8/src/extra/widgets/msgbox;../../../../components/lvgl_v8/src/extra/widgets/imgbtn;../../../../components/lvgl_v8/src/extra/libs/rlottie;../../../../components/lvgl_v8/src/extra/libs/freetype;../../../../components/lvgl_v8/src/misc;../../../../components/lvgl_v8/src/extra/widgets/chart;../../../../components/lvgl_v8/src/extra/libs/bmp;../../../../device/drivers;../../../../components/lvgl_v8/src/extra/widgets;../../../../components/lvgl_v8/src/extra/others;../../../../components/lvgl_v8/src/extra/widgets/win;../../../../components/lvgl_v8/src/widgets;../../../../device;../../../../components/lvgl_v8/src/extra/libs/fsdrv;../../../../components/lvgl_v8/src/core;../../../../components/lvgl_v8/src/extra/layouts;../../../../components/lvgl_v8/src/extra/others/snapshot;../../../../components/lvgl_v8/src/extra;../../../../components/lvgl_v8/src/extra/widgets/calendar;../../../../components/lvgl_v8/src/extra/widgets/led;../../../../components/lvgl_v8/src/extra/widgets/span;../../../../components/lvgl_v8/src/extra/widgets/spinbox;../../../../components/lvgl_v8/src
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ../../../../device/mdk/linker/mm32f3273g_flash.scf
  group application
    ../: board_init.c board_init.h clock_init.c clock_init.h lcd_st7796s.c lcd_st7796s.h lcd_st7796s_port.c lv_conf.h lv_port_disp.c lv_port_disp.h main.c pin_init.c pin_init.h
  group drivers
    ../../../../device/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_iwdg.c hal_iwdg.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_sdio.c hal_sdio.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../../../../device/: hal_device_registers.h mm32f3273g.h mm32f3273g_features.h system_mm32f3273g.c system_mm32f3273g.h
    ../../../../device/mdk/: startup_mm32f3273g.s
  group lvgl_v8
    ../../../../components/lvgl_v8/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../components/lvgl_v8/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../components/lvgl_v8/src/extra/: lv_extra.c
    ../../../../components/lvgl_v8/src/extra/layouts/flex/: lv_flex.c
    ../../../../components/lvgl_v8/src/extra/layouts/grid/: lv_grid.c
    ../../../../components/lvgl_v8/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../components/lvgl_v8/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../components/lvgl_v8/src/extra/themes/default/: lv_theme_default.c
    ../../../../components/lvgl_v8/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../components/lvgl_v8/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../components/lvgl_v8/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../components/lvgl_v8/src/extra/widgets/chart/: lv_chart.c
    ../../../../components/lvgl_v8/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../components/lvgl_v8/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../components/lvgl_v8/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../components/lvgl_v8/src/extra/widgets/led/: lv_led.c
    ../../../../components/lvgl_v8/src/extra/widgets/list/: lv_list.c
    ../../../../components/lvgl_v8/src/extra/widgets/meter/: lv_meter.c
    ../../../../components/lvgl_v8/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../components/lvgl_v8/src/extra/widgets/span/: lv_span.c
    ../../../../components/lvgl_v8/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../components/lvgl_v8/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../components/lvgl_v8/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../components/lvgl_v8/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../components/lvgl_v8/src/extra/widgets/win/: lv_win.c
    ../../../../components/lvgl_v8/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../components/lvgl_v8/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../components/lvgl_v8/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../components/lvgl_v8/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
