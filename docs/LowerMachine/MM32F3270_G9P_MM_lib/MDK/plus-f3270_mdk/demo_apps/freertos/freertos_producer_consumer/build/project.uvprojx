# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F3273G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APP_FREERTOS_PRODUCER_CONSUMER BRD_PLUS_F3270
  c include: ..;../../../../device/drivers;../../../../components/freertos/FreeRTOS-Kernel/portable/GCC/ARM_CM0;../../../../components/freertos/FreeRTOS-Kernel/include;../../../../device/CMSIS/Include;../../../../device
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ../../../../device/mdk/linker/mm32f3273g_flash.scf
  group application
    ../: FreeRTOSConfig.h board_init.c board_init.h clock_init.c clock_init.h main.c pin_init.c pin_init.h
  group drivers
    ../../../../device/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_iwdg.c hal_iwdg.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_sdio.c hal_sdio.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../../../../device/: hal_device_registers.h mm32f3273g.h mm32f3273g_features.h system_mm32f3273g.c system_mm32f3273g.h
    ../../../../device/mdk/: startup_mm32f3273g.s
  group freertos
    ../../../../components/freertos/FreeRTOS-Kernel/: tasks.c list.c queue.c timers.c stream_buffer.c croutine.c event_groups.c
    ../../../../components/freertos/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../../../components/freertos/FreeRTOS-Kernel/portable/GCC/ARM_CM0/: port.c portmacro.h
