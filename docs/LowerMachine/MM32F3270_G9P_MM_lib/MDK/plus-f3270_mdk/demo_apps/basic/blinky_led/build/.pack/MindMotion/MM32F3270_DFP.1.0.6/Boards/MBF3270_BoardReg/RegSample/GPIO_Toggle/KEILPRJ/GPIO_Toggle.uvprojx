# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F327x\Include;..\..\..\..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group USER
    ../USER/: main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
